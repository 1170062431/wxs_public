# Keil uVision project ca51f5.uvproj, settings and files
target CA51F5 (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: ca51f5 +hex
  c flags: Optimize=8 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Files
    ./source/: delay.c
    ./user/: user_io_cfg.c user_io_cfg.h timer0.c timer0.h timer1.c timer1.h pwm.c pwm.h main.c uart.c uart.h key.c key.h main.h
  group Lib
    ./lib/: STARTUP.A51
